# Keil uVision project SikendeRTOS.uvproj, settings and files
target SikendeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOS-lab1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  c include: .\;.\CMSIS;.\Inc;.\Src;.\Objects;.\Listings;.\HAL;.\RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./Src/: main.c Interpreter.c
  group Inc
    ./Inc/: retarget.h Interpreter.h FIFO.h
  group CMSIS
    ./CMSIS/: startup.s startup.h
  group HAL
    ./HAL/: tm4c123gh6pm.h cpu.h cpu.c PLL.c PLL.h cpu_vars.h UART0.c UART0.h
  group RTOS
    ./RTOS/: OS.c OS.h OSAsm.s OSConfig.h
